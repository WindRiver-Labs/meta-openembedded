FILESEXTRAPATHS_prepend := "${THISDIR}/python-urllib3:"

inherit pypi setuptools3
require python-urllib3.inc
