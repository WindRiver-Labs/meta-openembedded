PACKAGECONFIG_append = " tipc"
